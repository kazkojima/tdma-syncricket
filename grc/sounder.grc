options:
  parameters:
    author: kkojima
    generate_options: qt_gui
    id: sounder
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: att_rep
  id: variable
  parameters:
    value: 4/block_size
  states: {}
- name: block_size
  id: variable
  parameters:
    value: '6400'
  states: {}
- name: mic_vol
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: ref_coeff1
  id: variable
  parameters:
    value: '[0]*(block_size//2)+ref_vec1+[0]*(block_size//2-len(ref_vec1))'
  states: {}
- name: ref_coeff2
  id: variable
  parameters:
    value: '[0]*(block_size//2)+ref_vec2+[0]*(block_size//2-len(ref_vec2))'
  states: {}
- name: ref_coeff3
  id: variable
  parameters:
    value: '[0]*(block_size//2)+ref_vec3+[0]*(block_size//2-len(ref_vec3))'
  states: {}
- name: ref_coeff4
  id: variable
  parameters:
    value: '[0]*(block_size//2)+ref_vec4+[0]*(block_size//2-len(ref_vec4))'
  states: {}
- name: ref_coeff5
  id: variable
  parameters:
    value: '[0]*(block_size//2)+ref_vec5+[0]*(block_size//2-len(ref_vec5))'
  states: {}
- name: ref_vec1
  id: variable
  parameters:
    value: ref_spectrum_1.v1
  states: {}
- name: ref_vec2
  id: variable
  parameters:
    value: ref_spectrum_1.v2
  states: {}
- name: ref_vec3
  id: variable
  parameters:
    value: ref_spectrum_1.v3
  states: {}
- name: ref_vec4
  id: variable
  parameters:
    value: ref_spectrum_1.v4
  states: {}
- name: ref_vec5
  id: variable
  parameters:
    value: ref_spectrum_1.v5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64030'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: block_size
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters:
    vlen: block_size
  states: {}
- name: blocks_complex_to_mag_2
  id: blocks_complex_to_mag
  parameters:
    vlen: block_size
  states: {}
- name: blocks_complex_to_mag_3
  id: blocks_complex_to_mag
  parameters:
    vlen: block_size
  states: {}
- name: blocks_complex_to_mag_4
  id: blocks_complex_to_mag
  parameters:
    vlen: block_size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../dataset/output0.dat
    type: float
    vlen: block_size
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: ../dataset/output1.dat
    type: float
    vlen: block_size
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: ../dataset/output2.dat
    type: float
    vlen: block_size
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: ../dataset/output3.dat
    type: float
    vlen: block_size
  states: {}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    file: ../dataset/output4.dat
    type: float
    vlen: block_size
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mic_vol
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: block_size
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: block_size
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: block_size
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: block_size
  states: {}
- name: blocks_multiply_xx_4
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: block_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: block_size
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: block_size
  states: {}
- name: blocks_nlog10_ff_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: block_size
  states: {}
- name: blocks_nlog10_ff_3
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: block_size
  states: {}
- name: blocks_nlog10_ff_4
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: block_size
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: float
    vlen: block_size
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: block_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ref_coeff1
    vlen: block_size
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ref_coeff2
    vlen: block_size
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ref_coeff3
    vlen: block_size
  states: {}
- name: blocks_vector_source_x_3
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ref_coeff4
    vlen: block_size
  states: {}
- name: blocks_vector_source_x_4
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ref_coeff5
    vlen: block_size
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../wav/dining-1.wav
    repeat: 'False'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: block_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(block_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: block_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(block_size)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: block_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(block_size)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: block_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(block_size)
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: block_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(block_size)
  states: {}
- name: fft_vxx_3
  id: fft_vxx
  parameters:
    fft_size: block_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(block_size)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    nconnections: '5'
    vlen: block_size
    x_start: '0'
    x_step: '1.0'
    ymax: '1'
    ymin: '-10'
  states: {}
- name: ref_spectrum_1
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy as np\nff=open(\"../chirpset/filt1.cvd\", \"r\")\nv1=np.fromfile(ff, dtype=np.complex).tolist()\nff=open(\"../chirpset/filt2.cvd\", \"r\")\nv2=np.fromfile(ff, dtype=np.complex).tolist()\nff=open(\"../chirpset/filt3.cvd\", \"r\")\nv3=np.fromfile(ff, dtype=np.complex).tolist()\nff=open(\"../chirpset/filt4.cvd\", \"r\")\nv4=np.fromfile(ff, dtype=np.complex).tolist()\nff=open(\"../chirpset/filt5.cvd\", \"r\")\nv5=np.fromfile(ff, dtype=np.complex).tolist()\nff=open(\"../chirpset/filt6.cvd\", \"r\")\nv6=np.fromfile(ff, dtype=np.complex).tolist()\nff=open(\"../chirpset/filt7.cvd\", \"r\")\nv7=np.fromfile(ff, dtype=np.complex).tolist()\nff=open(\"../chirpset/filt8.cvd\", \"r\")\nv8=np.fromfile(ff, dtype=np.complex).tolist()\n\n"
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_nlog10_ff_1, '0']
- [blocks_complex_to_mag_2, '0', blocks_nlog10_ff_2, '0']
- [blocks_complex_to_mag_3, '0', blocks_nlog10_ff_3, '0']
- [blocks_complex_to_mag_4, '0', blocks_nlog10_ff_4, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0, '0', fft_vxx_0_1, '0']
- [blocks_multiply_xx_1, '0', fft_vxx_0, '0']
- [blocks_multiply_xx_2, '0', fft_vxx_1, '0']
- [blocks_multiply_xx_3, '0', fft_vxx_2, '0']
- [blocks_multiply_xx_4, '0', fft_vxx_3, '0']
- [blocks_nlog10_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_1, '0', blocks_file_sink_1, '0']
- [blocks_nlog10_ff_1, '0', blocks_null_sink_0, '0']
- [blocks_nlog10_ff_1, '0', qtgui_vector_sink_f_0, '1']
- [blocks_nlog10_ff_2, '0', blocks_file_sink_2, '0']
- [blocks_nlog10_ff_2, '0', blocks_null_sink_0, '1']
- [blocks_nlog10_ff_2, '0', qtgui_vector_sink_f_0, '2']
- [blocks_nlog10_ff_3, '0', blocks_file_sink_3, '0']
- [blocks_nlog10_ff_3, '0', blocks_null_sink_0, '2']
- [blocks_nlog10_ff_3, '0', qtgui_vector_sink_f_0, '3']
- [blocks_nlog10_ff_4, '0', blocks_file_sink_4, '0']
- [blocks_nlog10_ff_4, '0', blocks_null_sink_0, '3']
- [blocks_nlog10_ff_4, '0', qtgui_vector_sink_f_0, '4']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_vector_source_x_2, '0', blocks_multiply_xx_2, '1']
- [blocks_vector_source_x_3, '0', blocks_multiply_xx_3, '1']
- [blocks_vector_source_x_4, '0', blocks_multiply_xx_4, '1']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_1, '0']
- [fft_vxx_0_0, '0', blocks_multiply_xx_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_xx_1, '0']
- [fft_vxx_0_0, '0', blocks_multiply_xx_2, '0']
- [fft_vxx_0_0, '0', blocks_multiply_xx_3, '0']
- [fft_vxx_0_0, '0', blocks_multiply_xx_4, '0']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_1, '0', blocks_complex_to_mag_2, '0']
- [fft_vxx_2, '0', blocks_complex_to_mag_3, '0']
- [fft_vxx_3, '0', blocks_complex_to_mag_4, '0']

metadata:
  file_format: 1
